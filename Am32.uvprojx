# Keil uVision project Am32.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Am32 +hex
  c flags: Optim=7 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CM4\CoreSupport;.\CMSIS\CM4\DeviceSupport;.\AT32F4xx_StdPeriph_Driver\inc;.\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ./Src/: AT32F4xx_OPT.s
    ./CMSIS/CM4/DeviceSupport/: system_at32f421.c
    ./CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421.s
  group Src
    ./Src/: at32f4xx_it.c main.c eeprom.c
  group F4_Std
    ./AT32F4xx_StdPeriph_Driver/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
